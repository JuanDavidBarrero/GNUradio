options:
  parameters:
    author: Juan David Barrero
    description: 'como trabajar con archivos de audio o de texto '
    generate_options: qt_gui
    id: files
    output_language: python
    title: audio/file source
  states: {}

blocks:
- name: choose
  id: variable_qtgui_chooser
  parameters:
    label: musica o texto
    label0: Pasa alto
    label1: Pasa bajo
    label2: Pasa banda
    num_opts: '3'
    option0: '0'
    option1: '1'
    option2: '2'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: freq
    orient: Qt.Horizontal
    start: '0'
    step: '10'
    stop: 10e3
    value: '4000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    gain: '1'
    high_cutoff_freq: freq+1000
    interp: '1'
    low_cutoff_freq: freq
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '1000'
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '3'
    output_index: choose
    type: float
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: choose
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '16'
    file: C:\Users\USUARIO\Desktop\JuanDavid\GNURadio\AudioFile\nuevo_audio.wav
    samp_rate: samp_rate
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\USUARIO\Desktop\JuanDavid\GNURadio\AudioFile\audioTest_44100.wav
    repeat: 'True'
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: freq
    decim: '1'
    gain: '2'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: freq
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: firdes.WIN_HAMMING
  states: {}

connections:
- [band_pass_filter_0, '0', blocks_selector_0_0, '2']
- [blocks_selector_0, '0', high_pass_filter_0, '0']
- [blocks_selector_0, '1', low_pass_filter_0, '0']
- [blocks_selector_0, '2', band_pass_filter_0, '0']
- [blocks_selector_0_0, '0', audio_sink_0, '0']
- [blocks_selector_0_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_wavfile_source_0, '0', blocks_selector_0, '0']
- [high_pass_filter_0, '0', blocks_selector_0_0, '0']
- [low_pass_filter_0, '0', blocks_selector_0_0, '1']

metadata:
  file_format: 1
