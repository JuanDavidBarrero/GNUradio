options:
  parameters:
    author: Juan David Barrero
    description: Modulación Am de doble banda lateral portadora suprimida
    generate_options: qt_gui
    id: DSBSC
    output_language: python
    title: DSB_SC
  states: {}

blocks:
- name: amp
  id: variable_qtgui_range
  parameters:
    label: amplitud
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '10'
    value: '1'
  states: {}
- name: chooser
  id: variable_qtgui_chooser
  parameters:
    comment: |-
      Permite escoger la señal moduladora 
      se puede escoger entre 
      Tono     	|         Audio
    label: Tono  o Audio
    label0: Tomo
    label1: Audio
    num_opts: '2'
    option0: '0'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    comment: |-
      Permite cambiar la frecuancia de la señal 
      moduladora (TONO)
    label: frecuencia
    orient: Qt.Horizontal
    start: '0'
    step: '5'
    stop: '1000'
    value: '500'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: amp
    comment: |-
      Tono de la señal, esta se puede variar
      con el slider
    freq: freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: amp + 1
    comment: |-
      Señal portadora, esta debe tener una 
      frecuancia mayor a la de la moduladora
    freq: 10e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: Si se quiere comentar pulse la telca D
    samp_rate: samp_rate
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: chooser
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    comment: |-
      El audio debe estar
      en su PC !
    file: C:\Users\JuanD\Downloads\test.wav
    repeat: 'True'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: firdes.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: Para habilitar el bloque de audio presionar la tecla E
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Modulación AM DSB-SC"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: AM
    name: '"Modulación AM DSB-SC"'
    size: '256'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', audio_sink_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_selector_0, '0', blocks_multiply_xx_0, '0']
- [blocks_throttle_0, '0', blocks_selector_0, '0']
- [blocks_wavfile_source_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', blocks_selector_0, '1']

metadata:
  file_format: 1
