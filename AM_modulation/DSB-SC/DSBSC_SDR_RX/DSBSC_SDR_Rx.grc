options:
  parameters:
    author: Juan David Barrero L
    description: 'En este codigo se busca captar la señal transmitida '
    generate_options: qt_gui
    id: DSBSC_SDR_Rx
    output_language: python
    title: DSBSC Rx SDR
  states: {}

blocks:
- name: downSample
  id: variable
  parameters:
    value: '50'
  states: {}
- name: freq_c
  id: variable
  parameters:
    value: 150e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: samp_rate_RDS
  id: variable
  parameters:
    value: 44100*downSample
  states: {}
- name: vol
  id: variable_qtgui_range
  parameters:
    label: volumen
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '5'
    value: '1'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '2'
    comment: |-
      Señal portadora
      Debe ser la misma que se utilizo en la
      transmisión
    freq: '10000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    comment: |-
      Convierte la señal Q e I en una sola, 
      la cual si puede ser utilizado para 
      escuhar por el parlante del PC
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    comment: Permite controlar el volumen del audio
    const: vol
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 10e3
    decim: '1'
    gain: '2'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '1000'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Señal original"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"Señal Recuperada"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: |-
      Permite bajar el número de muestras 
      para que se pueda escuchar por 
      el altavoz del eqipo
    decim: downSample
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    bw0: 10e3
    comment: |-
      Bloque que permite escuhcar
      a la frecuencia espesificada
    freq0: freq_c
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate_RDS
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_complex_to_mag_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_xx_0, '0', audio_sink_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_xx_0, '0']
- [rtlsdr_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
