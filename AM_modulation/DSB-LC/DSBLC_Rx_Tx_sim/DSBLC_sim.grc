options:
  parameters:
    author: Juan David Barrero
    description: Demostración de rx y tx doble banda lateral gran portadora
    generate_options: qt_gui
    id: DSBLC_sim
    output_language: python
    title: 'DSBLC sim '
  states: {}

blocks:
- name: amp
  id: variable_qtgui_range
  parameters:
    label: Amplitud
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: '10'
    value: '1'
  states: {}
- name: choose
  id: variable_qtgui_chooser
  parameters:
    label: tono/musica
    label0: Tono
    label1: Musica
    num_opts: '2'
    option0: '0'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: freq_mod
  id: variable_qtgui_range
  parameters:
    label: frecuancia moduladora
    orient: Qt.Horizontal
    start: '0'
    step: '50'
    stop: '1000'
    value: '400'
  states: {}
- name: freq_portadora
  id: variable
  parameters:
    value: 5e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: freq_mod
    audio_stop: freq_mod+5000
    chan_rate: samp_rate
    comment: Permite demodular la señal AM
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: amp/5
    freq: freq_mod
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: amp
    comment: Señal portadora
    freq: freq_portadora
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    comment: Para bloquear bloque presione D
    samp_rate: samp_rate
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: amp*2
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    comment: |-
      Selecione entre un tono o la 
      señal de audio que se coloco
      previamente
    enabled: 'True'
    input_index: choose
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    comment: |-
      Selecionar una audio que este
      en el computador
    file: C:\Users\USUARIO\Desktop\JuanDavid\GNURadio\Multimedia\Foreigner_44100.wav
    repeat: 'True'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 5e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 5e3
    win: firdes.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: Transmisión AM
  states: {}
- name: note_1
  id: note
  parameters:
    note: Recepción AM
  states: {}
- name: note_2
  id: note
  parameters:
    note: Para debloquear el bloque precionar E
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    name: '"Espectro DSBLC"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    name: '"rtext"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"Modulación AM DSB-LC"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"Señal recupera"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: TX
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: TX
  states: {}

connections:
- [analog_am_demod_cf_0, '0', audio_sink_0_0, '0']
- [analog_am_demod_cf_0, '0', qtgui_freq_sink_x_0_0, '0']
- [analog_am_demod_cf_0, '0', qtgui_time_sink_x_0_0, '0']
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0, '1']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_add_xx_0, '0', virtual_sink_0, '0']
- [blocks_float_to_complex_0, '0', analog_am_demod_cf_0, '0']
- [blocks_multiply_const_xx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '0']
- [blocks_selector_0, '0', blocks_multiply_xx_0, '0']
- [blocks_throttle_0, '0', blocks_selector_0, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_const_xx_0, '0']
- [low_pass_filter_0, '0', blocks_selector_0, '1']
- [virtual_source_0, '0', blocks_float_to_complex_0, '0']

metadata:
  file_format: 1
