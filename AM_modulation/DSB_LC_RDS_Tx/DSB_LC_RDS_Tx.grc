options:
  parameters:
    author: 'Juan David Barrero '
    description: Recibir la señal enviada con tipo de modulación AM
    generate_options: qt_gui
    id: DSB_LC_RDS_Tx
    output_language: python
    title: DSB_LC_RDS_Tx
  states: {}

blocks:
- name: downSample
  id: variable
  parameters:
    value: '50'
  states: {}
- name: freq_mod
  id: variable
  parameters:
    value: 150e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: samp_rate_RDS
  id: variable
  parameters:
    value: samp_rate*downSample
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '5000'
    audio_stop: '5500'
    chan_rate: samp_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: downSample
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: freq_mod
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate_RDS
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_am_demod_cf_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_0, '0', analog_am_demod_cf_0, '0']
- [rtlsdr_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
