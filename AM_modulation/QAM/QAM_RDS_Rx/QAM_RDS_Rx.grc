options:
  parameters:
    author: Juan David Barrero L
    description: test
    generate_options: qt_gui
    id: test
    output_language: python
    title: QAM_SDR_Rx
  states: {}

blocks:
- name: choose
  id: variable_qtgui_chooser
  parameters:
    comment: Permite escoger el mensaje que se quiera oir
    label: mensaje
    label0: msg1
    label1: msg2
    num_opts: '2'
    option0: '0'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: downSample
  id: variable
  parameters:
    value: '50'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 150e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: samp_rate_RDS
  id: variable
  parameters:
    value: samp_rate*downSample
  states: {}
- name: vol
  id: variable_qtgui_range
  parameters:
    comment: Permite ajutar el volumen del audio
    label: volumen
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '1'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-10e3'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '10000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    comment: |-
      convierte la señal compleja en una señal 
      flotante
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: vol
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    comment: Selecionar el mensaje que se quiere oir
    enabled: 'True'
    input_index: choose
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 20e3
    decim: '1'
    gain: '2'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '1000'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 20e3
    decim: '1'
    gain: '2'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '1000'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: downSample
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    comment: |-
      Bloque receptor este tiene la 
      misma tasa de muestreo que se 
      ajusto en el transmisor
    freq0: freq
    gain0: '20'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate_RDS
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_xx_0, '0', audio_sink_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0_0, '0']
- [blocks_multiply_xx_0_0, '0', low_pass_filter_0, '0']
- [blocks_selector_0, '0', blocks_complex_to_mag_0, '0']
- [low_pass_filter_0, '0', blocks_selector_0, '0']
- [low_pass_filter_0_0, '0', blocks_selector_0, '1']
- [rational_resampler_xxx_0, '0', blocks_multiply_xx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_xx_0_0, '1']
- [rtlsdr_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
