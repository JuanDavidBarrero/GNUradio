options:
  parameters:
    author: Juan David Barrero
    generate_options: qt_gui
    id: DigitalTV
    output_language: python
    title: Televisión digital
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 429e6
  states: {}
- name: pilot_freq
  id: variable
  parameters:
    value: (6000000.0 - (symbol_rate / 2)) / 2
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 6.25e6
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: 4500000.0 / 286 * 684
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\JuanD\OneDrive\Escritorio\VideoRx.ts
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\USUARIO\Desktop\JuanDavid\GNURadio\Multimedia\VideoTX.ts
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: '832'
    n: '1024'
    offset: '4'
    type: byte
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: ((-3000000.0 + pilot_freq) / symbol_rate) * (math.pi * 2)
  states: {state: disabled}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: '1024'
    type: byte
  states: {}
- name: dtv_atsc_field_sync_mux_0
  id: dtv_atsc_field_sync_mux
  parameters: {}
  states: {}
- name: dtv_atsc_interleaver_0
  id: dtv_atsc_interleaver
  parameters: {}
  states: {}
- name: dtv_atsc_pad_0
  id: dtv_atsc_pad
  parameters: {}
  states: {}
- name: dtv_atsc_randomizer_0
  id: dtv_atsc_randomizer
  parameters: {}
  states: {}
- name: dtv_atsc_rs_encoder_0
  id: dtv_atsc_rs_encoder
  parameters: {}
  states: {}
- name: dtv_atsc_rx_0
  id: dtv_atsc_rx
  parameters:
    rate: symbol_rate
    sps: '1.5'
  states: {state: disabled}
- name: dtv_atsc_trellis_encoder_0
  id: dtv_atsc_trellis_encoder
  parameters: {}
  states: {}
- name: dtv_dvbs2_modulator_bc_0
  id: dtv_dvbs2_modulator_bc
  parameters:
    constellation: MOD_8VSB
    interpolation: INTERPOLATION_OFF
  states: {state: disabled}
- name: dtv_dvbt2_modulator_bc_0
  id: dtv_dvbt2_modulator_bc
  parameters:
    constellation: MOD_QPSK
    framesize: FECFRAME_NORMAL
    rotation: ROTATION_OFF
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: firdes.root_raised_cosine(0.11, symbol_rate, symbol_rate/2, 0.1152, 200)
    type: ccc
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '20'
    freq0: 460e6
    gain0: '10'
    if_gain0: '20'
    sample_rate: 48e3*50
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: symbol_rate
    fc: center_freq
    fftsize: '1024'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: mod-rot
  states: {state: disabled}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: mod-rot
  states: {state: disabled}

connections:
- [blocks_file_source_0, '0', dtv_atsc_pad_0, '0']
- [blocks_keep_m_in_n_0, '0', dtv_dvbs2_modulator_bc_0, '0']
- [blocks_keep_m_in_n_0, '0', dtv_dvbt2_modulator_bc_0, '0']
- [blocks_rotator_cc_0, '0', fft_filter_xxx_0, '0']
- [blocks_vector_to_stream_1, '0', blocks_keep_m_in_n_0, '0']
- [dtv_atsc_field_sync_mux_0, '0', blocks_vector_to_stream_1, '0']
- [dtv_atsc_interleaver_0, '0', dtv_atsc_trellis_encoder_0, '0']
- [dtv_atsc_pad_0, '0', dtv_atsc_randomizer_0, '0']
- [dtv_atsc_randomizer_0, '0', dtv_atsc_rs_encoder_0, '0']
- [dtv_atsc_rs_encoder_0, '0', dtv_atsc_interleaver_0, '0']
- [dtv_atsc_rx_0, '0', blocks_file_sink_0, '0']
- [dtv_atsc_trellis_encoder_0, '0', dtv_atsc_field_sync_mux_0, '0']
- [dtv_dvbs2_modulator_bc_0, '0', osmosdr_sink_0, '0']
- [dtv_dvbs2_modulator_bc_0, '0', qtgui_freq_sink_x_0, '0']
- [dtv_dvbs2_modulator_bc_0, '0', virtual_sink_0, '0']
- [dtv_dvbt2_modulator_bc_0, '0', osmosdr_sink_0, '0']
- [dtv_dvbt2_modulator_bc_0, '0', qtgui_freq_sink_x_0, '0']
- [fft_filter_xxx_0, '0', dtv_atsc_rx_0, '0']
- [fft_filter_xxx_0, '0', osmosdr_sink_0, '0']
- [fft_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0, '0', blocks_rotator_cc_0, '0']

metadata:
  file_format: 1
