options:
  parameters:
    author: Juan David Barrero
    generate_options: qt_gui
    id: Tx_RX_WBFM
    output_language: python
    title: Transmisión y recepción WBFM
  states: {}

blocks:
- name: chooser
  id: variable_qtgui_chooser
  parameters:
    label: Tono/audio
    label0: Tomo
    label1: Audio
    num_opts: '2'
    option0: '0'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    comment: |-
      Decuerdo a los parametros del transmisor
      este demodula la señal y permite 
      escucharla en los parlantes del equipo
    quad_rate: samp_rate*10
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: samp_rate*10
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: samp_rate*10
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: chooser
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\USUARIO\Desktop\JuanDavid\GNURadio\Multimedia\Metallica_44100.wav
    repeat: 'True'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 15e3
    gain: '1'
    interp: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: 1e3
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    comment: |-
      Para evitar que el ruido daña la recpeción 
      de la información se pone el siguiente filtro
    cutoff_freq: 20e3
    decim: '10'
    gain: '1'
    samp_rate: samp_rate*10
    type: fir_filter_fff
    width: 10e3
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate*100
    fc: '0'
    fftsize: '1024'
    name: '"Espectro modulación FM"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Espectro señal recuperada"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '10'
    taps: ''
    type: fff
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: '0'
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: '0'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_selector_0, '0']
- [analog_wfm_rcv_0, '0', low_pass_filter_0_0, '0']
- [analog_wfm_tx_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_wfm_tx_0, '0', virtual_sink_0, '0']
- [blocks_selector_0, '0', rational_resampler_xxx_0, '0']
- [blocks_wavfile_source_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', blocks_selector_0, '1']
- [low_pass_filter_0_0, '0', audio_sink_0, '0']
- [low_pass_filter_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_tx_0, '0']
- [virtual_source_0, '0', analog_wfm_rcv_0, '0']

metadata:
  file_format: 1
