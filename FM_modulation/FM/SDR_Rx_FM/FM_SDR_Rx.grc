options:
  parameters:
    author: JuanD
    generate_options: qt_gui
    id: FM_SDR_Rx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: downSample
  id: variable
  parameters:
    value: '50'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 150e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: samp_rate_RDS
  id: variable
  parameters:
    value: samp_rate*downSample
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    samp_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '15000'
    audio_stop: '16000'
    chan_rate: samp_rate_RDS
    deviation: '75000'
    gain: '5'
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"recibida"'
    size: '4000'
    srate: samp_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: downSample
    interp: '1'
    taps: ''
    type: fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate_RDS
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_fm_deemph_0, '0', audio_sink_0, '0']
- [analog_fm_deemph_0, '0', qtgui_time_sink_x_1_0, '0']
- [analog_fm_demod_cf_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_fm_deemph_0, '0']
- [rtlsdr_source_0, '0', analog_fm_demod_cf_0, '0']

metadata:
  file_format: 1
