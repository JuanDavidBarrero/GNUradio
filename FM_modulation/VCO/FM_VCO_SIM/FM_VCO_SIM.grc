options:
  parameters:
    author: JuanDavid Barrero
    generate_options: qt_gui
    id: FM_VCO_SIM
    output_language: python
    title: Simulación con vco
  states: {}

blocks:
- name: LPF
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 7.5e3
    gain: '1.0'
    samp_rate: samp_rate
    width: '500'
    win: firdes.WIN_HAMMING
  states: {}
- name: chooser
  id: variable_qtgui_chooser
  parameters:
    label: Tono/Audio
    label0: Tono
    label1: Audio
    num_opts: '2'
    option0: '0'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: freq
  id: variable
  parameters:
    value: 120e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 360e3
  states: {}
- name: vco_sens
  id: variable
  parameters:
    value: 2*math.pi*freq
  states: {}
- name: vol
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '2'
    value: '0.2'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '15000'
    audio_stop: '16000'
    chan_rate: '44100'
    comment: |-
      Permite captar  y demodular
      la señal FM
    deviation: '75000'
    gain: '5'
    tau: '75e-6'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '500'
    offset: '0'
    phase: '0'
    samp_rate: 48e3
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '15'
    gain: '1'
    high_cutoff_freq: 140e3
    low_cutoff_freq: 100e3
    samp_rate: samp_rate
    type: fir_filter_fcc
    width: 2e3
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      Controla el volumen de la señal
      captada
    const: vol
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.8'
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: chooser
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_vco_f_0
  id: blocks_vco_f
  parameters:
    amplitude: '1'
    comment: |-
      Para calcular la sensibilidad del VCO
      se utiliza la siguiente formula
      Vco_sens=2*Pi*F
    samp_rate: samp_rate
    sensitivity: vco_sens
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    comment: |-
      Selecione una audio que 
      este en su PC
    file: C:\Users\JuanD\Downloads\Nirvana_48000.wav
    repeat: 'True'
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Espectro de modulación FM"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Modulación FM"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"recibida"'
    size: '4000'
    srate: samp_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: |-
      Aumentar el número de muestrar para poder 
      alcanzar el tiempo de muestreo del VCO
    decim: '2'
    interp: '15'
    taps: LPF
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    comment: |-
      Se baja el numero de muestra 
      para poder ajustalo al del parlante
      del PC
    decim: '1'
    interp: '2'
    taps: ''
    type: ccc
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    comment: |-
      Salida de la estapa de transmisor 
      Este bloque se podria remplazar con el
      del OSMOCON SDR
      para transmitir la señal
    stream_id: '0'
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    comment: |-
      Entrada al receptor este bloque 
      se podria cambiar por RTL SOURCE
      con el fin de captarlo utilizando 
      el SDR
    stream_id: '0'
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_sig_source_x_0, '0', blocks_selector_0, '0']
- [band_pass_filter_0, '0', rational_resampler_xxx_1, '0']
- [blocks_add_const_vxx_0, '0', blocks_integrate_xx_0, '0']
- [blocks_integrate_xx_0, '0', blocks_vco_f_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_selector_0, '1']
- [blocks_selector_0, '0', rational_resampler_xxx_0, '0']
- [blocks_vco_f_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_vco_f_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_vco_f_0, '0', virtual_sink_0, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_const_vxx_1, '0']
- [rational_resampler_xxx_0, '0', blocks_add_const_vxx_0, '0']
- [rational_resampler_xxx_1, '0', analog_fm_demod_cf_0, '0']
- [virtual_source_0, '0', band_pass_filter_0, '0']

metadata:
  file_format: 1
