options:
  parameters:
    author: JuanD
    generate_options: qt_gui
    id: NBFM_RDS_Rx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: downSample
  id: variable
  parameters:
    value: '50'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 105.7e6
  states: {}
- name: lowPassFilter
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 16e3
    gain: '1.0'
    samp_rate: samp_rate
    width: 3e3
    win: firdes.WIN_HAMMING
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: samp_rate_RDS
  id: variable
  parameters:
    value: samp_rate*downSample
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: samp_rate
    max_dev: 5e3
    quad_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 10e3
    decim: '1'
    gain: '2'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 2e3
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Espectro de señal recibida"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: '"Señal recibida"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: downSample
    interp: '1'
    taps: lowPassFilter
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate_RDS
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_nbfm_rx_0, '0', low_pass_filter_1, '0']
- [low_pass_filter_1, '0', audio_sink_0, '0']
- [low_pass_filter_1, '0', qtgui_freq_sink_x_1, '0']
- [low_pass_filter_1, '0', qtgui_time_sink_x_1, '0']
- [rational_resampler_xxx_0, '0', analog_nbfm_rx_0, '0']
- [rtlsdr_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
