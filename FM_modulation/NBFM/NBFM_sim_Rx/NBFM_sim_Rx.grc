options:
  parameters:
    author: Juan David Barrero L
    description: Se mostrara como captar y demodular la señal transmida
    generate_options: qt_gui
    id: NBFM_sim_Rx
    output_language: python
    title: NBFM_rx
  states: {}

blocks:
- name: chooser
  id: variable_qtgui_chooser
  parameters:
    label: Tono o audio
    label0: Tono
    label1: Audio
    num_opts: '2'
    option0: '0'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: samp_rate
    comment: De modulador de FM banda angosta
    max_dev: 5e3
    quad_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: samp_rate
    comment: |-
      Transmisor de FM banda angosta
      con característica comercial
    fh: '-1.0'
    max_dev: 2e3
    quad_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 1e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: Para bloquer el bloque presione D
    samp_rate: samp_rate
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: chooser
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    comment: Selecione un audio de su PC
    file: C:\Users\USUARIO\Desktop\JuanDavid\GNURadio\Multimedia\Foreigner_44100.wav
    repeat: 'True'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 16e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 3e3
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 10e3
    decim: '1'
    gain: '2'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 2e3
    win: firdes.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: Para activar el bloque presione E
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate*10
    fc: '0'
    fftsize: '1024'
    name: '"NBFM"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Espectro de señal recibida"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"FM"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: '"Señal recibida"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: Tx
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: Tx
  states: {}

connections:
- [analog_nbfm_rx_0, '0', low_pass_filter_1, '0']
- [analog_nbfm_tx_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_nbfm_tx_0, '0', qtgui_time_sink_x_0, '0']
- [analog_nbfm_tx_0, '0', virtual_sink_0, '0']
- [analog_sig_source_x_0, '0', blocks_selector_0, '0']
- [blocks_selector_0, '0', analog_nbfm_tx_0, '0']
- [blocks_wavfile_source_0_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', blocks_selector_0, '1']
- [low_pass_filter_1, '0', audio_sink_0, '0']
- [low_pass_filter_1, '0', qtgui_freq_sink_x_1, '0']
- [low_pass_filter_1, '0', qtgui_time_sink_x_1, '0']
- [virtual_source_0, '0', analog_nbfm_rx_0, '0']

metadata:
  file_format: 1
