options:
  parameters:
    author: Juan David Barrero L
    description: Utilizando el HackRF se transmitira una señal de FM en la banda comercial con un mensaje propio
    generate_options: qt_gui
    id: NBFM_Tx
    output_language: python
    title: NBFM Tx SDR
  states: {}

blocks:
- name: chooser
  id: variable_qtgui_chooser
  parameters:
    label: Tono o audio
    label0: Tono
    label1: Audio
    num_opts: '2'
    option0: '0'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: freq
  id: variable
  parameters:
    value: 105.7e6
  states: {}
- name: low_pass
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 16e3
    gain: '1.0'
    samp_rate: samp_rate
    width: 3e3
    win: firdes.WIN_HAMMING
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: samp_rate_RDS
  id: variable
  parameters:
    value: samp_rate*upSample
  states: {}
- name: upSample
  id: variable
  parameters:
    value: '50'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: samp_rate
    fh: '-1.0'
    max_dev: 2e3
    quad_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: chooser
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\JuanD\OneDrive\Escritorio\JuanDavid\GNUradio\Multimedia\Metallica_44100.wav
    repeat: 'True'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 20e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 5e3
    win: firdes.WIN_HAMMING
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '20'
    freq0: freq
    gain0: '10'
    if_gain0: '20'
    sample_rate: samp_rate_RDS
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate*10
    fc: '0'
    fftsize: '1024'
    name: '"NBFM"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: upSample
    taps: ''
    type: ccc
  states: {}

connections:
- [analog_nbfm_tx_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_nbfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [analog_sig_source_x_0, '0', blocks_selector_0, '0']
- [blocks_selector_0, '0', analog_nbfm_tx_0, '0']
- [blocks_wavfile_source_0_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', blocks_selector_0, '1']
- [rational_resampler_xxx_0, '0', osmosdr_sink_0, '0']

metadata:
  file_format: 1
