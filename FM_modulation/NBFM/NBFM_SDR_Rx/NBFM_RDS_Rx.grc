options:
  parameters:
    author: JuanD
    generate_options: qt_gui
    id: NBFM_RDS_Rx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: downSample
  id: variable
  parameters:
    value: '50'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '105690000'
  states: {}
- name: freq_rds
  id: variable_qtgui_range
  parameters:
    label: freq_rds
    orient: Qt.Horizontal
    start: 99.7e6
    step: 5e3
    stop: 107.7e6
    value: freq
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: samp_rate_RDS
  id: variable
  parameters:
    value: samp_rate*downSample
  states: {}
- name: vol
  id: variable_qtgui_range
  parameters:
    label: vol
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: '10'
    value: '1'
    widget: slider
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: samp_rate
    max_dev: 5e3
    quad_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: '50'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 1e3
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 15e3
    decim: '1'
    gain: vol
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 5e3
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    name: '"Espectro de señal recibida"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: '"Señal recibida"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: downSample
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: freq_rds
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate_RDS
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_nbfm_rx_0, '0', low_pass_filter_0, '0']
- [high_pass_filter_0, '0', audio_sink_0, '0']
- [high_pass_filter_0, '0', qtgui_freq_sink_x_1, '0']
- [high_pass_filter_0, '0', qtgui_time_sink_x_1, '0']
- [low_pass_filter_0, '0', high_pass_filter_0, '0']
- [rational_resampler_xxx_0, '0', analog_nbfm_rx_0, '0']
- [rtlsdr_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
